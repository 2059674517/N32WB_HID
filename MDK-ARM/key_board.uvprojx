# Keil uVision project key_board.uvprojx, settings and files
target N32WB03x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: beacon
  AfterMake: fromelf --bin --output=.\bin\beacon.bin .\Objects\beacon.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32wb03x_std_periph_driver\inc;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\middlewares\Nationstech\ble_library\ns_library\adv;..\middlewares\Nationstech\ble_library\ns_library\timer;..\middlewares\Nationstech\ble_library\ns_library\log;..\middlewares\Nationstech\ble_library\ns_library\sleep;..\middlewares\Nationstech\ble_library\ns_library\delay;..\middlewares\Nationstech\ble_library\ns_library\sec;..\middlewares\Nationstech\ble_library\ns_library\ble;..\middlewares\Nationstech\ble_library\ns_ble_profile;..\middlewares\Nationstech\ble_library\ns_ble_stack;..\user;..\firmware\n32wb03x_std_periph_driver\inc;..\user\inc;..\user\src;..\user\inc\app_profile
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_lpuart.c n32wb03x_qflash.c n32wb03x_spi.c n32wb03x_i2c.c
  group BLE_STACK
    ../middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
    ../middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
  group BLE_PROFILE
    ../middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/bas/bass/src/: bass_task.c bass.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/hogp/hogpd/src/: hogpd_task.c hogpd.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/rdts/: rdts_common.c
  group NS_LIB
    ../middlewares/Nationstech/ble_library/ns_library/log/: ns_log_lpuart.c ns_log_usart.c
    ../middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    ../middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
    ../middlewares/Nationstech/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
    ../middlewares/Nationstech/ble_library/ns_library/timer/: ns_timer.c
  group BLE_APP
    ../user/src/: app_ble.c
    ../user/src/app_profile/: app_dis.c app_batt.c app_hid.c
  group USER
    ../user/src/: main.c app_hid_keyboard.c app_gpio.c app_hid_touchscreen.c
  group CONFIG
    ../user/inc/: app_user_config.h
